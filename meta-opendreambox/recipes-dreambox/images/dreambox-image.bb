IMAGE_PKGTYPE = "deb"
PROVIDES = "dreambox-image-deb"

require dreambox-image.inc
require dreambox-image-signing.inc
