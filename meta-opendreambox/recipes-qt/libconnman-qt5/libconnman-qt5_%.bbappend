SRC_URI_remove = "git://git.merproject.org/mer-core/libconnman-qt.git;protocol=https"
SRC_URI += "git://github.com/sailfishos/libconnman-qt.git;protocol=https;branch=master"
