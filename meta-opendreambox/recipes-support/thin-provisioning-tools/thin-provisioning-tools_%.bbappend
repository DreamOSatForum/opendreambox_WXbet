SRC_URI_remove = "git://github.com/jthornber/thin-provisioning-tools"
SRC_URI += "git://github.com/jthornber/thin-provisioning-tools;protocol=https;branch=main"
